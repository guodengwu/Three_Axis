# Keil uVision project C51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ThreeAxis +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\INC;..\STC_LIB;..\BSP;..\USER
  asm include: ..\INC
  group Source Group 1
    ./: main.c STARTUP.A51
  group STC_LIB
    ../STC_LIB/: USART.C GPIO.c timer.c
  group BSP
    ../BSP/: bsp.c bsp_printf.c
  group USER
    ../USER/: ring_buffer.c protocol.c misc.c sys.c motor.c encoder.c
